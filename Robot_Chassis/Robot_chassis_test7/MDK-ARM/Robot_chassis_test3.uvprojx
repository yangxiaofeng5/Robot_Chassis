# Keil uVision project Robot_chassis_test3.uvprojx, settings and files
target Robot_chassis_test3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Robot_chassis_test3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,USE_HAL_DRIVER,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M,_GUNC_
  c include: ../Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;       ../Middlewares/Third_Party/FreeRTOS/Source/include;       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;       ../Drivers/CMSIS/Include;       ..\Drivers\CMSIS\Lib\ARM;       ..\DSB_LIB;       ..\DSB_LIB\Include;       ..\APP\User_lib;       ..\APP\robomaster_vcan;       ..\APP\chassis_behaviour;       ..\APP\Gimbal_behaviour;       ..\APP\robomaster_filter;       ..\Hardware\Bsp-can;       ..\Hardware\DJI_Remote;       ..\Hardware\oled;       ..\Hardware\IMU;       ..\Task\Initial_Task;       ..\Task\Chassis_Task;       ..\Task\Gimbal_Task;       ..\Task\Revolver_Task;       ..\Task\Test_Task;       ..\APP\Robot_Status;    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c freertos.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User_lib
    ../DSB_LIB/: arm_cortexM4lf_math.lib
    ../DSB_LIB/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group Task
    ../Task/Initial_Task/: Initial_Task.c
    ../Task/Revolver_Task/: Revolver_Task.c
    ../Task/Test_Task/: Test_Task.c
    ../Task/Gimbal_Task/: Gimbal_Task1.c
    ../Task/Chassis_Task/: Chassis_Task.c
  group APP
    ../APP/robomaster_vcan/: robomaster_vcan.c
    ../APP/User_lib/: User_lib.c
    ../APP/chassis_behaviour/: chassis_behaviour.c
    ../APP/robomaster_filter/: robomaster_filter.c
    ../APP/Robot_Status/: Robot_Status.c
  group Hardware
    ../Hardware/Bsp-can/: bsp_can.c pid.c
    ../Hardware/DJI_Remote/: dji_remote.c
    ../Hardware/oled/: oled.c
    ../Hardware/IMU/: bsp_imu.c
  group 开发日志
    ./: 开发日志.txt
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
